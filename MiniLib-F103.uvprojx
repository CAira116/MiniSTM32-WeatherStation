# Keil uVision project MiniLib-F103.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\template\Drivers\CMSIS\Include;..\template\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../template/MDK-ARM/: startup_stm32f103xb.s
    ./: main.c gpio.h gpio.c rcc.c systick.c rcc.h usart.c usart.h exti.c exti.h timer.c timer.h i2c.c i2c.h dht11.c dht11.h bmp280.c bh1750.c spi.c spi.h systick.h bmp280.h bh1750.h esp8266.h esp8266.c
